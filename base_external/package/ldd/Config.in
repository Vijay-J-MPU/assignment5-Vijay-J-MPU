## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
    help
    	Contains the starter code needed for the assignment
```
